options:
  parameters:
    author: gui_sdr_gps_sim
    description: Receive IQ from gui_sdr_gps_sim TCP/UDP output, visualize, retransmit via HackRF
    generate_options: qt_gui
    id: gps_network_to_hackrf
    output_language: python
    title: 'gui_sdr_gps_sim: Network Stream to HackRF TX'
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: GPS L1 C/A center frequency Hz
    value: '1575420000'
  states: {}
- name: fft_avg
  id: variable_qtgui_range
  parameters:
    comment: FFT time-average (0=freeze 1=live)
    label: FFT Average alpha
    start: '0.01'
    step: '0.01'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Must match app Sample Rate setting (default 3 MSPS)
    value: '3000000'
  states: {}
- name: tcp_addr
  id: variable
  parameters:
    comment: IP where the app is running (TCP server)
    value: '"127.0.0.1"'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    comment: Port set in app TCP output setting
    value: '4567'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF TX VGA gain
    label: TX VGA Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: udp_port
  id: variable
  parameters:
    comment: Port GR listens on (set app UDP address to 127.0.0.1:this_port)
    value: '4567'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    comment: |-
      i8 interleaved IQ bytes → complex float ±1.0
      scale = 1/128 to normalise
    scale_factor: 1.0/128.0
    vector_input: 'False'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: Decimate 100x for time-domain scope
    n: '100'
    type: complex
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: tcp_addr
    comment: |-
      TCP client — connects to app TCP server.
      App setting: Output = TCP, port = 4567.
    port: tcp_port
    server: 'False'
    type: byte
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    comment: |-
      UDP source — GR listens, app sends datagrams.
      App setting: Output = UDP, destination = 127.0.0.1:4567.
      Disabled by default — enable and disable TCP source to switch.
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '32768'
    port: udp_port
    src_zeros: 'False'
    type: byte
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    bw0: '3000000'
    comment: |-
      HackRF One TX @ GPS L1 1575.42 MHz.
      if_gain0 = tx_gain slider (TX VGA, 0–47 dB).
      gain0 = 0 (amp off) or 14 (amp on).
      NOTE: GRC osmosdr template may hardcode 100 MHz — the generated .py fixes this to center_freq.
    freq0: 1575.42e6
    gain0: '0'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.4'
    autoscale: 'True'
    comment: I vs Q scatter. GPS C/A is noise-like without a correlator.
    grid: 'True'
    gui_hint: tabs@3
    label1: GPS L1
    name: '"GPS L1 C/A \u2014 Constellation"'
    size: '8192'
    tr_level: '0'
    type: complex
    update_time: '0.1'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"cyan"'
    comment: GPS L1 C/A appears as a 2 MHz wide noise hump at 1575.42 MHz
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: tabs@0
    label: GPS L1 C/A Spectrum
    label1: IQ stream
    name: '"GPS L1 C/A \u2014 FFT Spectrum"'
    norm_window: 'True'
    type: complex
    update_time: '0.05'
    ymax: '-40'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    comment: I (cyan) and Q (red) after 100x decimation
    grid: 'True'
    gui_hint: tabs@2
    label1: I
    label2: Q
    name: '"GPS L1 C/A \u2014 Time Domain (dec x100)"'
    size: '1024'
    srate: samp_rate/100
    tr_level: '0'
    type: complex
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
    yunit: '"norm."'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Time vs frequency heatmap
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: tabs@1
    int_max: '40'
    int_min: '-40'
    name: '"GPS L1 C/A \u2014 Waterfall"'
    type: complex
    update_time: '0.05'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,1
    label0: FFT Spectrum
    label1: Waterfall
    label2: Time Domain
    label3: Constellation
    num_tabs: '4'
  states: {}

connections:
- [blocks_interleaved_char_to_complex_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [network_tcp_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [network_udp_source_0, '0', blocks_interleaved_char_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

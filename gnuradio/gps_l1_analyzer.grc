options:
  parameters:
    author: gui_sdr_gps_sim
    description: Analyze GPS L1 C/A output from gui_sdr_gps_sim via a second HackRF in RX mode
    generate_options: qt_gui
    id: gps_l1_analyzer
    output_language: python
    title: GPS L1 C/A Signal Analyzer
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: GPS L1 C/A carrier frequency Hz
    value: '1575420000'
  states: {}
- name: fft_avg
  id: variable_qtgui_range
  parameters:
    comment: FFT time-average (0=freeze 1=live)
    label: FFT Average alpha
    start: '0.01'
    step: '0.01'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF RX LNA gain (0-40 dB steps of 8)
    label: LNA Gain (dB)
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF RX VGA gain (0-62 dB steps of 2)
    label: VGA Gain (dB)
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '30'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: Decimate 100x for time-domain scope
    n: '100'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: numchan=1 hackrf=0
    bb_gain0: vga_gain
    bw0: samp_rate
    comment: HackRF One RX
    freq0: 100e6
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: lna_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@3
    label1: GPS L1
    name: '"GPS L1 C/A \u2014 Constellation"'
    size: '4096'
    tr_level: '0'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: tabs@0
    label: GPS L1 C/A Spectrum
    label1: HackRF RX
    name: '"GPS L1 C/A \u2014 FFT Spectrum"'
    type: complex
    update_time: '0.05'
    ymax: '-50'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@2
    label1: I
    label2: Q
    name: '"GPS L1 C/A \u2014 Time Domain (dec x100)"'
    size: '1024'
    srate: samp_rate/100
    tr_level: '0'
    type: complex
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    gui_hint: tabs@1
    int_max: '-50'
    int_min: '-120'
    name: '"GPS L1 C/A \u2014 Waterfall"'
    type: complex
    update_time: '0.05'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,1
    label0: FFT Spectrum
    label1: Waterfall
    label2: Time Domain
    label3: Constellation
    num_tabs: '4'
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_keep_one_in_n_0, '0']
- [osmosdr_source_0, '0', qtgui_const_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

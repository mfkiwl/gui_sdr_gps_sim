options:
  parameters:
    author: gui_sdr_gps_sim
    description: Receive GPS IQ from app UDP output, retransmit via HackRF
    generate_options: qt_gui
    id: gps_udp_to_hackrf_simple
    output_language: python
    title: GPS UDP to HackRF (simple)
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: GPS L1 C/A Hz
    value: '1575420000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF TX VGA gain 0-47 dB
    label: TX VGA Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: udp_port
  id: variable
  parameters:
    comment: App UDP destination port
    value: '4567'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    comment: i8 IQ bytes -> complex float +-1.0
    scale_factor: 1.0/128.0
    vector_input: 'False'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    comment: |-
      App setting: Output = UDP
      destination = 127.0.0.1:4567
      Start GR first, then start the app.
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '32768'
    port: udp_port
    src_zeros: 'False'
    type: byte
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    comment: |-
      HackRF TX @ 1575.42 MHz
      if_gain = tx_gain slider
    freq0: 1575.42e6
    gain0: '0'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_interleaved_char_to_complex_0, '0', osmosdr_sink_0, '0']
- [network_udp_source_0, '0', blocks_interleaved_char_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
